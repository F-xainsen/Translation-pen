# Keil uVision project boot.uvproj, settings and files
target BK3435_bim (5050041::V5.05 (build 41)::.\ARMCC)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: bk3633_boot
  AfterMake: fromelf --bin --output .\output\bk3633_boot.bin .\obj\bk3633_boot.axf
  AfterMake: .\output\encrypt_bim.bat
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  c include: .\app;.\usb\include;.\usb;.\usb\include;.\usb\include\class;.\usb\src\cd;.\usb\src\drivers\comm;.\usb\src\drivers\msd;.\usb\src\examples;.\usb\src\functions\trans_fn;.\usb\src\systems\none;.\usb\src\systems\none\afs;.\usb\src\test;.\usb\src\test\msd;.\usb\src\drivers;.\usb\usb
  asm include: .\src\plf\refip\src\arch\ll
  library: MicroLIB
  scatter file: .\lnk\link_bim.txt
  link misc: --entry sys_Reset
  group bim
    ./app/: bim_app.c bim_intc.c bim_updataImage.c bim_vectors.s bim_handlers.s bim_flash.c bim_gpio.c bim_icu.c bim_wdt.c rf_xvr.c bim_adc.c bim_uart2.c
  group usb
    ./usb/src/cd/: mu_cntlr.c mu_descs.c mu_drc.c mu_fc.c mu_fdr.c mu_fun.c mu_hc.c mu_hdr.c mu_hst.c mu_list.c mu_pip.c
    ./usb/: driver_usb.c
    ./usb/src/examples/msd/: mu_msdfn.c
    ./usb/src/functions/trans_fn/: mu_tfunc.c
    ./usb/src/systems/none/afs/: board.c
    ./usb/src/systems/none/: plat_uds.c
    ./usb/src/test/msd/: tst_msd.c
  group usb_driver
    ./usb/: driver_usb.c
    ./usb/usb/: usb.c usb_desc.c usbclass.c
