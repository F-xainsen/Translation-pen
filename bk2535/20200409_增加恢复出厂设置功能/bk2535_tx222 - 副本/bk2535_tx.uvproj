# Keil uVision project bk2535_tx.uvproj, settings and files
target Target 1 (MCS-51)
  device: DS80C320 Dallas Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: bk2535 +hex
  AfterMake: "E:\2019工作项目（叶坤）\2.4G\20190624-巨资\20200325_增加配对\20200409_增加恢复出厂设置功能\bk2535_tx222 - 副本\GenTXT.BAT"
  c flags: Optimize=9 SizeSpeed=1
  c include: .;.\mcu;.\mcu\usb
  group a51
    ./: STARTUP.A51
  group MCU
    ./MCU/: utils.c MCUInital.c timer.c AD.c _rf.c nvr.c rf.c main.c global.c keys.c Function.c pairfunc.c sleep.c
