# Keil uVision project Beken_Turnkey_BK5100_Dongle_V1.0.uvproj, settings and files
target Target 1 (MCS-51)
  device: DS80C320 Dallas Semiconductor
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: bk_fw +hex
  AfterMake: "E:\2019工作项目（叶坤）\2.4G\20190624-巨资\20200325_增加配对\20200409_增加恢复出厂设置功能\dongle - 副本（改描述）\output\GenTXT.BAT"
  c flags: Optimize=9
  group application
    ./application/: application_main.c application_mode_page.c application_mode_normal.c application_rf.c application_mode_test.c
  group driver
    ./driver/: driver_initial.c driver_interrupt.c driver_memory.c driver_rf.c driver_usb_standard_requests.c driver_timer.c driver_uart.c driver_usb_descriptor.c driver_usb_interrupt.c
